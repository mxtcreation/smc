DESCRIPTON = "add german keyboard layout"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0010-add-german-layout.patch"
