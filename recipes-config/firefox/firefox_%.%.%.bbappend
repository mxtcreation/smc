DESCRIPTON = "Remove firefox from blacklist or it can not be built"
PNBLACKLIST[firefox] = ""
