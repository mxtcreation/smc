DESCRIPTON = "Remove chromium from blacklist or it can not be built"
PNBLACKLIST[chromium] = ""
