DESCRIPTON = "fix ls command in Xsession shell"

FILESEXTRAPATHS_prepend := "${THISDIR}/xserver-common:"
SRC_URI += "file://0017-fix-ls-command.patch"
